# IAR project clock_bm_cm7.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK; _BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa092
  ICCARM.CCIncludePath2: ..; ../../../vglite_support; ../../../../../../components/video; ../../../../../../components/video/display; ../../../../../../components/video/display/rm68191; ../../../../../../devices/MIMXRT1176/drivers; ../../../../../../components/video/display/mipi_dsi_cmd; ../../../../../../components/video/display/rm68200; ../../../../../../components/video/display/dc/lcdifv2; ../../../../../../middleware/vglite/inc; ../../../../../../middleware/vglite/font; ../../../../../../middleware/vglite/font/mcufont/decoder; ../../../../../../middleware/vglite/VGLite/bm; ../../../../../../middleware/vglite/VGLiteKernel; ../../../../../../middleware/vglite/VGLiteKernel/bm; ../../../../../../middleware/vglite/elementary/inc; ../../../../../../middleware/vglite/elementary/src; ../../../../../../components/video/display/dc/elcdif; ../../../../../../components/video/display/hx8394; ../../../../../../components/video/display/fbdev; ../../../../../../devices/MIMXRT1176; ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMXRT1176/xip; ../../../../xip; ../../../../../../devices/MIMXRT1176/drivers/cm7; ../../../../../../CMSIS/Core/Include; ../../../../../../components/video/display/dc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: clock_bm_cm7.out
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; VG_RESOLVE_ENGINE=0; VG_PE_COLOR_KEY=0; VG_IM_INDEX_FORMAT=0; VG_AYUV_INPUT_OUTPUT=0; VG_DOUBLE_IMAGE=0; VG_RECTANGLE_STRIP_MODE=0; VG_MMU=0; VG_IM_FILTER=0; VG_IM_YUV_PACKET=1; VG_IM_YUV_PLANAR=0; VG_PE_YUV_PACKET=1; VG_TARGET_TILED=1; VG_COMMAND_CALL=1; VG_SHARE_BUFFER_IM_16K=0; VG_OFFLINE_MODE=0; VG_RESOLUTION_2880=0; VG_PE_PREMULTIPLY=0; VG_POST_CONVERTER=0; VG_PRE_CONVERTER=0; VG_RENDER_BY_MESH=0; VG_TARGET_FAST_CLEAR=0; VG_BUFFER_NUMBER_OF_TARGET=0; VG_VIDEO_CLEAR_CONTROL=0; VG_VIDEO_CONTROL=0; VGLITE_TST_FIRMWARE=0; VG_LITE_SYS_GPU_CTRL=0; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK; _BAREMETAL
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; _BAREMETAL
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_DEBUGCONSOLE_UART; MCUXPRESSO_SDK; _BAREMETAL
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h pin_mux.c pin_mux.h
    ../../../vglite_support/: vglite_support.c vglite_support.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MIMXRT1176/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_pmu.c fsl_pmu.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h
    ../../../../../../devices/MIMXRT1176/drivers/cm7/: fsl_cache.c fsl_cache.h
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group source
    ../: clock_analog.h clock_bm.c hour_needle.h minute_needle.h
  group startup
    ../../../../../../devices/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../../../../../devices/MIMXRT1176/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group vglite
    ../../../../../../middleware/vglite/: ChangeLogKSDK.txt
  group vglite/elementary/inc
    ../../../../../../middleware/vglite/elementary/inc/: Elm.h
  group vglite/elementary/src
    ../../../../../../middleware/vglite/elementary/src/: elm_buffer.c elm_draw.c elm_headers.h elm_init.c elm_object.c elm_os.c elm_os.h elm_precom.h elm_text.c elm_text.h velm.h
  group vglite/font
    ../../../../../../middleware/vglite/font/: buf_reader.c buf_reader.h fonts.h rle_font_read.c vft_debug.c vft_debug.h vft_draw.c vft_draw.h vg_lite_text.c
  group vglite/font/mcufont
    ../../../../../../middleware/vglite/font/mcufont/: LICENSE
  group vglite/font/mcufont/decoder
    ../../../../../../middleware/vglite/font/mcufont/decoder/: mcufont.h mf_bwfont.c mf_bwfont.h mf_config.h mf_encoding.c mf_encoding.h mf_font.c mf_font.h mf_justify.c mf_justify.h mf_kerning.c mf_kerning.h mf_rlefont.c mf_rlefont.h mf_scaledfont.c mf_scaledfont.h mf_wordwrap.c mf_wordwrap.h
  group vglite/inc
    ../../../../../../middleware/vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../../../../../../middleware/vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/bm
    ../../../../../../middleware/vglite/VGLite/bm/: vg_lite_os.c vg_lite_os.h
  group vglite/VGLiteKernel
    ../../../../../../middleware/vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group vglite/VGLiteKernel/bm
    ../../../../../../middleware/vglite/VGLiteKernel/bm/: vg_lite_hal.c vg_lite_platform.h
  group video
    ../../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
    ../../../../../../components/video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../../../../../components/video/display/: fsl_display.h
    ../../../../../../components/video/display/hx8394/: fsl_hx8394.c fsl_hx8394.h
    ../../../../../../components/video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h
    ../../../../../../components/video/display/rm68191/: fsl_rm68191.c fsl_rm68191.h
    ../../../../../../components/video/display/rm68200/: fsl_rm68200.c fsl_rm68200.h
    ../../../../../../components/video/: fsl_video_common.c fsl_video_common.h
  group xip
    ../../../../xip/: evkmimxrt1170_flexspi_nor_config.c evkmimxrt1170_flexspi_nor_config.h
    ../../../../../../devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
